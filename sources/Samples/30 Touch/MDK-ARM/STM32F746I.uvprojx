# Keil uVision project STM32F746I.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746I Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,__STRICT_ANSI__
  c misc: --C99
  c include: ..\..\..\common\stm32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc;..\Inc;..\..\..\common\stm32CubeF7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\common\stm32CubeF7\Drivers\CMSIS\Include;..\..\..\common\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../../common/stm32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../../../common/stm32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../common/stm32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_uart.c
    ../../../common/stm32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal_uart.h
  group Application/User
    ../Inc/: dma.h dma2d.h fmc.h gpio.h i2c.h ltdc.h mxconstants.h stm32f7xx_hal_conf.h stm32f7xx_it.h usart.h
    ../Src/: main.cpp dma.cpp dma2d.cpp fmc.cpp image.h image1.h image2.h gpio.cpp i2c.cpp image.cpp ltdc.cpp stm32f7xx_hal_msp.cpp usart.cpp stm32f7xx_it.c
  group BSP
    ../../../common/BSP/: GT811.h stm32746g_lcd.h stm32746g_sdram.h TS_I2C.h GT811.cpp stm32746g_lcd.cpp stm32746g_sdram.cpp TS_I2C.cpp
software components: CMSIS:CORE 4.1.0
